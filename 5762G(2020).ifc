Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-01-22T16:06:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 22 16:06:55 2020 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{663778B5-818E-48CE-8AC4-C139152A26C6}\ifc * Database version: 5507 * Database creation date: Wed Jan 22 16:06:54 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 22 16:06:54 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 22 16:06:54 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 5762G Shower faucet with spout, 5762G(2020):5762G Shower faucet with spout:395934
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 183.228 mm; NominalHeight: 80.4245 mm; NominalWidth: 289.167 mm; Projection: 168 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 5762G(2020); ConvergoRefNr: 0087-1911-0008-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 04/12/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150091315; EN Standard: EN 1111; LVI Number: 6310865
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/5762G; Catalog Drawing URL: http://static.oras.com/catdrw/5762G; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/5762G; FDV Document URL: http://www.oras.com/datasheet/5762G/en/fdv; Group: Shower faucets; Long Marketing: Thermostatic shower faucet with spout and ergonomic drop shape handles. Temperature handle equipped with safety stop at 38°C. Volume handle with diverter and EcoFlow control. The faucet is equipped with cover plates (triple sealed). The faucet includes litter filters and non-return valves.; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 5762G Shower faucet with spout; Name_en: 5762G Shower faucet with spout; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 294 x 164 x 83; Package Weight: 2.208 kg; Product Code: 5762G; Product Datasheet: http://www.oras.com/datasheet/5762G/en; Product Family: Oras Care; Product Image URL: http://static.oras.com/image/5762G; Product URL: http://static.oras.com/5762G; Type Name: 5762G Shower faucet with spout; Usage Group: Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass; Aerator: HONEYCOMB®; Connection: With Cover Plates; Connection Size: G3/4; Diverter: Integrated diverter / Volume control; Installation and Maintenance: http://static.oras.com/manual/5762G; Installation Type: Wall mounted; Installation Width: CC150± 3 mm; Lever Handle: Temperature control handle;Flow control handle;; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part;Non-return valve(s);Litter filter(s); Mounting Holes: 2MountingHoles; Not Included: Without Couplings; Spare Parts: http://static.oras.com/sp/5762G; Spout Type: Fixed spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5762G(2020); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5762G; Name: 5762G Shower faucet with spout; ReplacementCost: n/a; Shape: Sculptured; Size: 290x185x80 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Safety Sales Arguments: THERMO COOL. Improved safety – the housing of the fittings conducts minimal heat.
Pset_ManufacturerTypeInformation - ModelReference: 5762G; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 5762G Shower faucet with spout
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0945714 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00429085 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 5762G(2020): 5762G Shower faucet with spout; Family and Type: 5762G(2020): 5762G Shower faucet with spout; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5762G(2020): 5762G Shower faucet with spout; Type Id: 5762G(2020): 5762G Shower faucet with spout; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
